# Keil uVision project HC32F460JCTA.uvprojx, settings and files
target HC32F460JCTA_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460JCTA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HC32F460JCTA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460jcta.s
    ../../common/: system_hc32f460jcta.c
  group source
    ../source/: main.c
target HC32F460JCTA_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460JCTA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: as above
  output: HC32F460JCTA +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
