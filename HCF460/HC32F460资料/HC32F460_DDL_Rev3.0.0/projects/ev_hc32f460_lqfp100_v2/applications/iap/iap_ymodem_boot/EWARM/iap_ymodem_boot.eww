<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iap_ymodem_boot.ewp</path>
  </project>
  <batchBuild/>
</workspace>


