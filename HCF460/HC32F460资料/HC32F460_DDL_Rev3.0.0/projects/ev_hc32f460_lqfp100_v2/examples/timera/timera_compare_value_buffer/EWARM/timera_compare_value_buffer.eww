<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timera_compare_value_buffer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


