<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\emb_pwm_brake_timer4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


