<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer6_32bit.ewp</path>
  </project>
  <batchBuild/>
</workspace>


