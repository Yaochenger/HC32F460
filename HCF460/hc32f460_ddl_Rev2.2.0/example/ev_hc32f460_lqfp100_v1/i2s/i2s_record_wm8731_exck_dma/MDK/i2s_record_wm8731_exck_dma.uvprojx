# Keil uVision project i2s_record_wm8731_exck_dma.uvprojx, settings and files
target i2s_record_wm8731_exck_dma_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: i2s_record_wm8731_exck_dma
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\..\mcu\common;..\source;..\..\..\..\..\driver\inc;..\..\..\..\..\midware\wm8731\inc;..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v1;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000c00 size 0x3FC
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ../../../../../mcu/common/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../../../../../driver/src/: hc32f460_pwc.c hc32f460_i2s.c hc32f460_efm.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_utility.c hc32f460_exint_nmi_swi.c hc32f460_sram.c hc32f460_i2c.c hc32f460_keyscan.c hc32f460_clk.c hc32f460_gpio.c hc32f460_dmac.c
  group wm8731
    ../../../../../midware/wm8731/src/: data_sound_441_i2s.c data_sound_8k_i2s.c wm8731.c
  group ev_hc32f460_lqfp100_v1
    ../../../../../bsp/ev_hc32f460_lqfp100_v1/: ev_hc32f460_lqfp100_v1.c
  group Readme
    ../: Readme.txt
target i2s_record_wm8731_exck_dma_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2s_record_wm8731_exck_dma +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 4.1.0
