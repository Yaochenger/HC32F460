# IAR project usb_dev_cdc_msc.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\midware\w25qxx\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_dev_cdc_msc.srec
  ILINK.IlinkOutputFile: usb_dev_cdc_msc.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../driver/src/: hc32f460_pwc.c hc32f460_efm.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_utility.c hc32f460_exint_nmi_swi.c hc32f460_sram.c hc32f460_qspi.c hc32f460_usart.c hc32f460_keyscan.c hc32f460_clk.c hc32f460_gpio.c
  group midware/w25qxx
    ../../../../../midware/w25qxx/src/: w25qxx.c
  group bsp/ev_hc32f460_lqfp100_v1
    ../../../../../bsp/ev_hc32f460_lqfp100_v1/: ev_hc32f460_lqfp100_v1.c
  group source
    ../source/: main.c
    ..//source/: cdc_data_process.c usb_bsp.c usb_dev_desc.c usb_dev_msc_msd.c usb_dev_user.c
